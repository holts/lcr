# Keil uVision project UsingRTX51Tiny.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: UsingRTX51Tiny +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: LCD_PG12864F.c main.c nx_C51.c HardWare.h LCD_PG12864F.h nx_c51.h CONF_TNY.A51 STARTUP.A51 T6963.c T6963.h GUI.h
